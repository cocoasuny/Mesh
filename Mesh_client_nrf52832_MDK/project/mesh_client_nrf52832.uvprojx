# Keil uVision project mesh_client_nrf52832.uvprojx, settings and files
target mesh_nrf52832_client (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD FREERTOS NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=6 S132 SOFTDEVICE_PRESENT __HEAP_SIZE=1024 __STACK_SIZE=2048
  c misc: --reduce_paths
  c include: ..\source\Application\inc;..\source\BSP\inc;..\source\Middllewares\fprintf;..\source\Middllewares\freertos\config;..\source\Middllewares\freertos\source\include;..\source\Middllewares\freertos\portable;..\source\Middllewares\freertos\portable\ARM\nrf52;..\source\Middllewares\freertos\portable\CMSIS\nrf52;..\source\nRF_BLE_Services\inc;..\source\nRF5_SDK_15.2.0_9412b96\modules\nrfx;..\source\nRF5_SDK_15.2.0_9412b96\modules\nrfx\hal;..\source\nRF5_SDK_15.2.0_9412b96\modules\nrfx\drivers\include;..\source\nRF5_SDK_15.2.0_9412b96\components\libraries\util;..\source\nRF5_SDK_15.2.0_9412b96\components\softdevice\s132\headers;..\source\nRF5_SDK_15.2.0_9412b96\components\ble\ble_advertising;..\source\nRF5_SDK_15.2.0_9412b96\components\ble\common;..\source\nRF5_SDK_15.2.0_9412b96\components\ble\nrf_ble_qwr;..\source\nRF5_SDK_15.2.0_9412b96\components\ble\nrf_ble_gatt;..\source\nRF5_SDK_15.2.0_9412b96\components\ble\peer_manager;..\source\nRF5_SDK_15.2.0_9412b96\components\libraries\timer;..\source\nRF5_SDK_15.2.0_9412b96\components\libraries\atomic;..\source\nRF5_SDK_15.2.0_9412b96\components\libraries\atomic_flags;..\source\nRF5_SDK_15.2.0_9412b96\components\libraries\log;..\source\nRF5_SDK_15.2.0_9412b96\components\libraries\log\src;..\source\nRF5_SDK_15.2.0_9412b96\components\libraries\mutex;..\source\nRF5_SDK_15.2.0_9412b96\components\libraries\fds;..\source\nRF5_SDK_15.2.0_9412b96\integration\nrfx;..\source\nRF5_SDK_15.2.0_9412b96\integration\nrfx\legacy;..\source\nRF5_SDK_15.2.0_9412b96\components\boards;..\source\nRF5_SDK_15.2.0_9412b96\components\libraries\experimental_section_vars;..\source\nRF5_SDK_15.2.0_9412b96\components\softdevice\common;..\source\nRF5_SDK_15.2.0_9412b96\components\libraries\strerror;..\source\nRF5_SDK_15.2.0_9412b96\components\libraries\button;..\source\nRF5_SDK_15.2.0_9412b96\components\libraries\bsp;..\source\nRF5_SDK_15.2.0_9412b96\components\libraries\sensorsim;..\source\nRF5_SDK_15.2.0_9412b96\components\libraries\memobj;..\source\nRF5_SDK_15.2.0_9412b96\components\libraries\balloc;..\source\nRF5_SDK_15.2.0_9412b96\components\libraries\atomic_fifo;..\source\nRF5_SDK_15.2.0_9412b96\components\libraries\ringbuf;..\source\nRF5_SDK_15.2.0_9412b96\components\libraries\fstorage;..\source\nRF5_SDK_15.2.0_9412b96\components\libraries\cli;..\source\nRF5_SDK_15.2.0_9412b96\components\libraries\queue;..\source\nRF5_SDK_15.2.0_9412b96\components\libraries\cli\uart;..\source\nRF5_SDK_15.2.0_9412b96\components\libraries\delay;..\source\nRF5_SDK_15.2.0_9412b96\components\libraries\pwr_mgmt;..\source\nRF5_SDK_15.2.0_9412b96\external\fnmatch
  asm define: as above
  asm misc: --cpreproc_opts=-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DFREERTOS,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_SD_BLE_API_VERSION=6,-DS132,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=1024,-D__STACK_SIZE=2048
  asm include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\components\ble\ble_racp;..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\..\..\..\components\ble\ble_services\ble_cscs;..\..\..\..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\components\ble\ble_services\ble_gls;..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\components\ble\ble_services\ble_hts;..\..\..\..\..\..\components\ble\ble_services\ble_ias;..\..\..\..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\..\..\..\components\ble\ble_services\ble_lbs;..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\..\components\ble\ble_services\ble_lls;..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\..\..\..\components\ble\ble_services\ble_rscs;..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\..\components\ble\ble_services\ble_tps;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\nrf_ble_gatt;..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\usbd;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\components\libraries\atomic_flags;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bootloader\ble_dfu;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\cli;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\components\libraries\crypto;..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\components\libraries\ecc;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\experimental_task_manager;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\gfx;..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\components\libraries\hardfault\nrf52;..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\components\libraries\mpu;..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\components\libraries\pwr_mgmt;..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\sdcard;..\..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\components\libraries\sortlist;..\..\..\..\..\..\components\libraries\spi_mngr;..\..\..\..\..\..\components\libraries\stack_guard;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\svc;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\twi_mngr;..\..\..\..\..\..\components\libraries\twi_sensor;..\..\..\..\..\..\components\libraries\usbd;..\..\..\..\..\..\components\libraries\usbd\class\audio;..\..\..\..\..\..\components\libraries\usbd\class\cdc;..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\..\components\libraries\usbd\class\hid;..\..\..\..\..\..\components\libraries\usbd\class\hid\generic;..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd;..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse;..\..\..\..\..\..\components\libraries\usbd\class\msc;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser;..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ac_rec;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_oob_advdata;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_lib;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_msg;..\..\..\..\..\..\components\nfc\ndef\connection_handover\common;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ep_oob_rec;..\..\..\..\..\..\components\nfc\ndef\connection_handover\hs_rec;..\..\..\..\..\..\components\nfc\ndef\connection_handover\le_oob_rec;..\..\..\..\..\..\components\nfc\ndef\generic\message;..\..\..\..\..\..\components\nfc\ndef\generic\record;..\..\..\..\..\..\components\nfc\ndef\launchapp;..\..\..\..\..\..\components\nfc\ndef\parser\message;..\..\..\..\..\..\components\nfc\ndef\parser\record;..\..\..\..\..\..\components\nfc\ndef\text;..\..\..\..\..\..\components\nfc\ndef\uri;..\..\..\..\..\..\components\nfc\t2t_lib;..\..\..\..\..\..\components\nfc\t2t_lib\hal_t2t;..\..\..\..\..\..\components\nfc\t2t_parser;..\..\..\..\..\..\components\nfc\t4t_lib;..\..\..\..\..\..\components\nfc\t4t_lib\hal_t4t;..\..\..\..\..\..\components\nfc\t4t_parser\apdu;..\..\..\..\..\..\components\nfc\t4t_parser\cc_file;..\..\..\..\..\..\components\nfc\t4t_parser\hl_detection_procedure;..\..\..\..\..\..\components\nfc\t4t_parser\tlv;..\..\..\..\..\..\components\softdevice\common;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\external\freertos\config;..\..\..\..\..\..\external\freertos\portable\ARM\nrf52;..\..\..\..\..\..\external\freertos\portable\CMSIS\nrf52;..\..\..\..\..\..\external\freertos\source\include;..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\external\utf_converter;..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\..\modules\nrfx\mdk;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5a000
  memory RVCT9: RAM 0x200057b8 size 0xa848
  link misc: --diag_suppress 6330
  group Application
    ../source/Application/src/: main.c cli_cmd.c
    ../source/Application/inc/: sdk_config.h platform.h
  group BSP
    ../source/BSP/src/: boards.c bsp.c bsp_btn_ble.c
  group Middleware/FreeRTOS
    ../source/Middllewares/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../source/Middllewares/freertos/source/portable/MemMang/: heap_1.c
    ../source/Middllewares/freertos/portable/ARM/nrf52/: port.c
    ../source/Middllewares/freertos/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
  group Middleware/utf_converter
    ../source/Middllewares/utf_converter/: utf.c
  group nRF_BLE
    ../source/nRF5_SDK_15.2.0_9412b96/components/ble/peer_manager/: auth_status_tracker.c gatts_cache_manager.c gatt_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c peer_manager_handler.c pm_buffer.c security_dispatcher.c security_manager.c
    ../source/nRF5_SDK_15.2.0_9412b96/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../source/nRF5_SDK_15.2.0_9412b96/components/ble/ble_advertising/: ble_advertising.c
    ../source/nRF5_SDK_15.2.0_9412b96/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../source/nRF5_SDK_15.2.0_9412b96/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
  group nRF_BLE_Services
    ../source/nRF_BLE_Services/src/: ble_bas.c ble_dis.c ble_hrs.c
  group nRF_Drivers
    ../source/nRF5_SDK_15.2.0_9412b96/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c
    ../source/nRF5_SDK_15.2.0_9412b96/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_power_clock.c nrfx_uart.c nrfx_uarte.c nrfx_power.c
    ../source/nRF5_SDK_15.2.0_9412b96/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../source/nRF5_SDK_15.2.0_9412b96/components/libraries/button/: app_button.c
    ../source/nRF5_SDK_15.2.0_9412b96/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../source/nRF5_SDK_15.2.0_9412b96/components/libraries/timer/: app_timer_freertos.c
    ../source/nRF5_SDK_15.2.0_9412b96/components/libraries/crc16/: crc16.c
    ../source/nRF5_SDK_15.2.0_9412b96/components/libraries/fds/: fds.c
    ../source/nRF5_SDK_15.2.0_9412b96/components/libraries/hardfault/nrf52/handler/: hardfault_handler_keil.c
    ../source/nRF5_SDK_15.2.0_9412b96/components/libraries/hardfault/: hardfault_implementation.c
    ../source/nRF5_SDK_15.2.0_9412b96/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../source/nRF5_SDK_15.2.0_9412b96/components/libraries/atomic_flags/: nrf_atflags.c
    ../source/nRF5_SDK_15.2.0_9412b96/components/libraries/atomic/: nrf_atomic.c
    ../source/nRF5_SDK_15.2.0_9412b96/components/libraries/balloc/: nrf_balloc.c
    ../source/Middllewares/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../source/nRF5_SDK_15.2.0_9412b96/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../source/nRF5_SDK_15.2.0_9412b96/components/libraries/memobj/: nrf_memobj.c
    ../source/nRF5_SDK_15.2.0_9412b96/components/libraries/ringbuf/: nrf_ringbuf.c
    ../source/nRF5_SDK_15.2.0_9412b96/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../source/nRF5_SDK_15.2.0_9412b96/components/libraries/strerror/: nrf_strerror.c
    ../source/nRF5_SDK_15.2.0_9412b96/components/libraries/sensorsim/: sensorsim.c
    ../source/nRF5_SDK_15.2.0_9412b96/components/libraries/cli/: nrf_cli.c
    ../source/nRF5_SDK_15.2.0_9412b96/components/libraries/cli/uart/: nrf_cli_uart.c
    ../source/nRF5_SDK_15.2.0_9412b96/external/fnmatch/: fnmatch.c
    ../source/nRF5_SDK_15.2.0_9412b96/components/libraries/queue/: nrf_queue.c
  group nRF_Log
    ../source/nRF5_SDK_15.2.0_9412b96/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../source/Middllewares/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../source/nRF5_SDK_15.2.0_9412b96/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_freertos.c nrf_sdh_soc.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.17.0
