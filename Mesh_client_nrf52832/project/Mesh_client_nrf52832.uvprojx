# Keil uVision project Mesh_client_nrf52832.uvprojx, settings and files
target Mesh_client_nrf52832 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Mesh_client_nrf52832 +hex
  AfterMake: find "Total R" ./Listings/Mesh_client_nRF52832.map
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF_MESH_TEST_BUILD=1 BEARER_ACCESS_ADDR_DEFAULT=0x527851DC NRF52 NRF52_SERIES  NRF52832 NRF52832_XXAA  S132 SOFTDEVICE_PRESENT SD_BLE_API_VERSION=5 NRF_SD_BLE_API_VERSION=5  CONFIG_GPIO_AS_PINRESET
  c include: ..\source\Application;..\source\MiddleWare\micro-ecc;..\source\MiddleWare\rtt\include;..\source\MiddleWare\rtt;..\source\nRF5_SDK_for_52832\components;..\source\nrf5_SDK_for_Mesh;..\source\nRF5_SDK_for_52832\components\softdevice\s132;..\source\nRF5_SDK_for_52832\components\softdevice\s132\headers;..\source\nrf5_SDK_for_Mesh\mesh\prov\include;..\source\nrf5_SDK_for_Mesh\mesh\prov\api;..\source\nRF5_SDK_for_52832\components\boards;..\source\nRF5_SDK_for_52832\components\drivers_nrf\hal;..\source\nRF5_SDK_for_52832\components\libraries\util;..\source\nrf5_SDK_for_Mesh\mesh\core\api;..\source\nrf5_SDK_for_Mesh\mesh\core\include;..\source\nrf5_SDK_for_Mesh\mesh\dfu\include;..\source\nrf5_SDK_for_Mesh\mesh\dfu\api;..\source\nrf5_SDK_for_Mesh\mesh\bearer\include;..\source\nrf5_SDK_for_Mesh\mesh\bearer\api;..\source\nRF5_SDK_for_52832\components\drivers_nrf\delay;..\source\nrf5_SDK_for_Mesh\mesh\access\include;..\source\nrf5_SDK_for_Mesh\mesh\access\api;..\source\nrf5_SDK_for_Mesh\models\config\include;..\source\nrf5_SDK_for_Mesh\models\health\include;..\source\nrf5_SDK_for_Mesh\models\simple_on_off\include;..\source\nRF5_SDK_for_52832\components\libraries\uart;..\source\nRF5_SDK_for_52832\components\libraries\fifo;..\source\nRF5_SDK_for_52832\components\drivers_nrf\common;..\source\nRF5_SDK_for_52832\components\drivers_nrf\uart;..\source\nRF5_SDK_for_52832\components\libraries\experimental_log;..\source\nRF5_SDK_for_52832\components\libraries\experimental_section_vars;..\source\nRF5_SDK_for_52832\components\libraries\experimental_log\src;..\source\nRF5_SDK_for_52832\components\libraries\experimental_memobj;..\source\nRF5_SDK_for_52832\components\libraries\balloc;..\source\nRF5_SDK_for_52832\components\libraries\strerror;..\source\BSP;..\source\nRF5_SDK_for_52832\components\libraries\cli;..\source\nRF5_SDK_for_52832\components\libraries\cli\uart;..\source\nRF5_SDK_for_52832\components\libraries\atomic;..\source\nRF5_SDK_for_52832\components\libraries\queue;..\source\MiddleWare\fprintf;..\source\nRF5_SDK_for_52832\components\libraries\experimental_ringbuf;..\source\nRF5_SDK_for_52832\components\libraries\pwr_mgmt;..\source\nRF5_SDK_for_52832\components\libraries\timer
  library: MicroLIB
  memory RVCT4: ROM 0x23000 size 0x5d000
  memory RVCT9: RAM 0x200031b0 size 0xce50
  group Application
    ../source/Application/: main.c nrf_mesh_sdk.c nrf_mesh_weak.c provisioner.c simple_hal.c nrf_mesh_config_app.h common.h sdk_config.h platform.h Global_Typedef.h
  group bsp
    ../source/BSP/: bsp.c bsp_uart.c bsp_cli.c
  group MeshModel/Configuration
    ../source/nrf5_SDK_for_Mesh/models/config/src/: config_client.c
  group MeshModel/Health
    ../source/nrf5_SDK_for_Mesh/models/health/src/: health_client.c
  group MehsModel/SimpleOnOff
    ../source/nrf5_SDK_for_Mesh/models/simple_on_off/src/: simple_on_off_client.c
  group MiddleWare/micro-ecc
    ../source/MiddleWare/micro-ecc/: uECC.c
  group MiddleWare/rtt
    ../source/MiddleWare/rtt/src/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group SDK52832/nRF_Drivers
    ../source/nRF5_SDK_for_52832/components/drivers_nrf/common/: nrf_drv_common.c
    ../source/nRF5_SDK_for_52832/components/drivers_nrf/uart/: nrf_drv_uart.c
  group SDK52832/Libraries
    ../source/nRF5_SDK_for_52832/components/libraries/uart/: app_uart_fifo.c retarget.c
    ../source/nRF5_SDK_for_52832/components/libraries/fifo/: app_fifo.c
    ../source/nRF5_SDK_for_52832/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c
    ../source/nRF5_SDK_for_52832/components/libraries/timer/: app_timer.c
    ../source/nRF5_SDK_for_52832/components/libraries/balloc/: nrf_balloc.c
    ../source/nRF5_SDK_for_52832/components/libraries/cli/: nrf_cli.c
    ../source/nRF5_SDK_for_52832/components/libraries/cli/uart/: nrf_cli_uart.c
    ../source/MiddleWare/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../source/nRF5_SDK_for_52832/components/libraries/experimental_memobj/: nrf_memobj.c
    ../source/nRF5_SDK_for_52832/components/libraries/queue/: nrf_queue.c
    ../source/nRF5_SDK_for_52832/components/libraries/experimental_ringbuf/: nrf_ringbuf.c
  group SDKMesh/Access
    ../source/nrf5_SDK_for_Mesh/mesh/access/src/: access.c access_publish.c access_reliable.c device_state_manager.c
  group SDKMesh/Bearer
    ../source/nrf5_SDK_for_Mesh/mesh/bearer/src/: ad_type_filter.c adv_packet_filter.c advertiser.c bearer_handler.c broadcast.c filter_engine.c gap_address_filter.c radio_config.c rssi_filter.c scanner.c
    ../source/nrf5_SDK_for_Mesh/mesh/prov/src/: prov_bearer_adv.c
  group SDKMesh/Core
    ../source/nrf5_SDK_for_Mesh/mesh/core/src/: aes.c aes_cmac.c beacon.c bearer_event.c cache.c ccm_soft.c core_tx.c enc.c event.c fifo.c flash_manager.c flash_manager_defrag.c flash_manager_internal.c hal.c internal_event.c log.c mesh_flash.c msg_cache.c msqueue.c net_beacon.c net_state.c network.c nrf_flash.c nrf_mesh.c nrf_mesh_configure.c nrf_mesh_keygen.c nrf_mesh_opt.c nrf_mesh_utils.c packet_buffer.c packet_mgr.c queue.c rand.c replay_cache.c ticker.c timer.c timer_scheduler.c timeslot.c toolchain.c transport.c uri.c
  group SDKMesh/Provisioning
    ../source/nrf5_SDK_for_Mesh/mesh/prov/src/: nrf_mesh_prov.c prov_beacon.c prov_provisioner.c prov_utils.c provisioning.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.15.0
