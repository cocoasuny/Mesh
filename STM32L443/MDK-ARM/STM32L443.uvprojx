# Keil uVision project STM32L443.uvprojx, settings and files
target STM32L443 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L433VCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32L443 +hex
  AfterMake: find "Total R" ./Listings/STM32L443.map
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L433xx,ARM_MATH_CM4,__FPU_PRESENT=1
  c misc: --C99
  c include: ..\Source\Application;..\Source\Bsp;..\Source\Drivers;..\Source\Library\CMSIS;..\Source\Library\CMSIS\Include;..\Source\Library\STM32L4xx_HAL_Driver;..\Source\Library\STM32L4xx_HAL_Driver\Src;..\Source\Library\STM32L4xx_HAL_Driver\Inc;..\Source\Library\CMSIS\Device\ST\STM32L4xx\Include;..\Source\Middlewares\Third_Party\FatFs;..\Source\Middlewares\Third_Party\FreeRTOS;..\Source\Shell;..\Source\Middlewares\Third_Party\FatFs\src;..\Source\Middlewares\Third_Party\FreeRTOS\Source\include;..\Source\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\Source\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\Source\Middlewares\CloudCare\Arithmetic
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Drivers/CMSIS
    ../Source/Library/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Application/MDK-ARM
    ../Source/Library/CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l443xx.s
  group Application/User
    ../Source/Application/: main.c freertos.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_TIM.c communication.c stm32l4xx_it.c platform.h FreeRTOSConfig.h stm32l4xx_hal_conf.h moniter_template.c immediately_measure.c battery_manage.c data_memory_manage.c
  group Bsp
    ../Source/Bsp/: bsp.c bsp_uart.c bsp_rtc.c StoreManageFatfs.c bsp_communication.c ymodem.c
  group Shell
    ../Source/Shell/: shell.c rtc_shell.c fatfs_shell.c
  group Drivers/BSP
    ../Source/Drivers/: led.c mx25l06e.c spi.c bma2x2.c bma250e.c afe4403.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Source/Library/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dma.c stm32l4xx_hal_firewall.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hcd.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_irda.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lcd.c stm32l4xx_hal_lptim.c stm32l4xx_hal_nand.c stm32l4xx_hal_nor.c stm32l4xx_hal_opamp.c stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sd.c stm32l4xx_hal_smartcard.c stm32l4xx_hal_smartcard_ex.c stm32l4xx_hal_smbus.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_swpmi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_tsc.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_wwdg.c stm32l4xx_ll_adc.c stm32l4xx_ll_comp.c stm32l4xx_ll_crc.c stm32l4xx_ll_crs.c stm32l4xx_ll_dac.c stm32l4xx_ll_dma.c stm32l4xx_ll_exti.c stm32l4xx_ll_fmc.c stm32l4xx_ll_gpio.c stm32l4xx_ll_i2c.c stm32l4xx_ll_lptim.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_opamp.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_rng.c stm32l4xx_ll_rtc.c stm32l4xx_ll_sdmmc.c stm32l4xx_ll_spi.c stm32l4xx_ll_swpmi.c stm32l4xx_ll_tim.c stm32l4xx_ll_usart.c stm32l4xx_ll_usb.c
  group Middlewares/FreeRTOS
    ../Source/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Source/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Source/Middlewares/Third_Party/FreeRTOS/Source/: timers.c event_groups.c queue.c list.c tasks.c croutine.c
    ../Source/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FatFs
    ../Source/Middlewares/Third_Party/FatFs/src/: ff.c diskio.c ff_gen_drv.c
    ../Source/Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/Arithmetic
    ../Source/Middlewares/CloudCare/Arithmetic/: cc_alg_app_interface.c SpO2HrCalCZT.lib
  group Doc
    ../Source/Application/: readMe.txt
software components: CMSIS:DSP 1.4.6
