# Keil uVision project Mesh_service_nRF51822.uvprojx, settings and files
target Mesh_service_nRF51822 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Mesh_service_nRF51822 +hex
  AfterMake: find "Total R" ./Listings/Mesh_service_nRF51822.map
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: NRF51822 S130 NRF_SD_BLE_API_VERSION=2 NRF51 SOFTDEVICE_PRESENT NRF_MESH_TEST_BUILD=1 BEARER_ACCESS_ADDR_DEFAULT=0x527851DC SD_BLE_API_VERSION=2 NRF51_SERIES  CONFIG_GPIO_AS_PINRESET
  c include: ..\source\Application;..\source\BSP;..\source\Drivers;..\source\MiddleWare\micro-ecc;..\source\nRF5_SDK_for_51822\components;..\source\nrf5_SDK_for_Mesh\mesh\access\include;..\source\nrf5_SDK_for_Mesh\mesh\app;..\source\nrf5_SDK_for_Mesh\mesh\bearer\include;..\source\nrf5_SDK_for_Mesh\mesh\core\include;..\source\nrf5_SDK_for_Mesh\mesh\dfu\include;..\source\nrf5_SDK_for_Mesh\mesh\prov\include;..\source\nrf5_SDK_for_Mesh\models\config\include;..\source\nrf5_SDK_for_Mesh\models\health\include;..\source\nrf5_SDK_for_Mesh\models\pb_remote\include;..\source\nrf5_SDK_for_Mesh\models\simple_on_off\include;..\source\nrf5_SDK_for_Mesh\tools;..\source\nRF5_SDK_for_51822\components\softdevice\common\softdevice_handler;..\source\nrf5_SDK_for_Mesh\mesh\prov\api;..\source\nrf5_SDK_for_Mesh\mesh\core\api;..\source\nrf5_SDK_for_Mesh\mesh\core\include;..\source\nrf5_SDK_for_Mesh\mesh\dfu\api;..\source\nRF5_SDK_for_51822\components\boards;..\source\nRF5_SDK_for_51822\components\drivers_nrf\hal;..\source\nRF5_SDK_for_51822\components\libraries\util;..\source\nrf5_SDK_for_Mesh\mesh\bearer\api;..\source\nRF5_SDK_for_51822\components\drivers_nrf\delay;..\source\nRF5_SDK_for_51822\components\softdevice\s130\headers;..\source\nrf5_SDK_for_Mesh\mesh\access\api;..\source\MiddleWare\rtt\include;..\source\nRF5_SDK_for_51822\components\libraries\uart;..\source\nRF5_SDK_for_51822\components\drivers_nrf\common;..\source\nRF5_SDK_for_51822\components\libraries\log;..\source\nRF5_SDK_for_51822\components\libraries\log\src;..\source\nRF5_SDK_for_51822\components\libraries\fifo;..\source\nRF5_SDK_for_51822\components\drivers_nrf\uart
  asm include: ..\source\nRF5_SDK_for_51822\components\toolchain
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x25000
  memory RVCT9: RAM 0x200033b0 size 0x4c50
  group Application
    ../source/Application/: main.c nrf_mesh_sdk.c nrf_mesh_weak.c simple_hal.c nrf_mesh_config_app.h common.h sdk_config.h platform.h
  group bsp
    ../source/BSP/: bsp.c bsp_uart.c
  group Drivers
    ../source/nRF5_SDK_for_51822/components/drivers_nrf/common/: nrf_drv_common.c
    ../source/nRF5_SDK_for_51822/components/drivers_nrf/uart/: nrf_drv_uart.c
  group Mesh_Model/Configuration
    ../source/nrf5_SDK_for_Mesh/models/config/src/: composition_data.c config_server.c packed_index_list.c
  group Mesh_Model/Health
    ../source/nrf5_SDK_for_Mesh/models/health/src/: health_server.c
  group Mesh_Model/SimpleOnOff
    ../source/nrf5_SDK_for_Mesh/models/simple_on_off/src/: simple_on_off_server.c
  group Middleware/micro-ecc
    ../source/MiddleWare/micro-ecc/: uECC.c
  group Middleware/rtt
    ../source/MiddleWare/rtt/src/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group SDK_51822/Libraries
    ../source/nRF5_SDK_for_51822/components/libraries/fifo/: app_fifo.c
    ../source/nRF5_SDK_for_51822/components/libraries/uart/: app_uart_fifo.c retarget.c
    ../source/nRF5_SDK_for_51822/components/libraries/util/: app_error.c app_error_weak.c
  group SDK_Mesh/Access
    ../source/nrf5_SDK_for_Mesh/mesh/access/src/: access.c access_publish.c access_reliable.c device_state_manager.c nrf_mesh_node_config.c
  group SDK_Mesh/Bearer
    ../source/nrf5_SDK_for_Mesh/mesh/bearer/src/: ad_type_filter.c adv_packet_filter.c advertiser.c bearer_handler.c broadcast.c filter_engine.c gap_address_filter.c radio_config.c rssi_filter.c scanner.c
    ../source/nrf5_SDK_for_Mesh/mesh/prov/src/: prov_bearer_adv.c
  group SDK_Mesh/Core
    ../source/nrf5_SDK_for_Mesh/mesh/core/src/: aes.c aes_cmac.c beacon.c bearer_event.c cache.c ccm_soft.c core_tx.c enc.c event.c fifo.c flash_manager.c flash_manager_defrag.c flash_manager_internal.c hal.c internal_event.c log.c mesh_flash.c msg_cache.c msqueue.c net_beacon.c net_state.c network.c nrf_flash.c nrf_mesh.c nrf_mesh_configure.c nrf_mesh_keygen.c nrf_mesh_opt.c nrf_mesh_utils.c packet_buffer.c packet_mgr.c queue.c rand.c replay_cache.c ticker.c timer.c timer_scheduler.c timeslot.c toolchain.c transport.c uri.c
  group SDK_Mesh/Provisioning
    ../source/nrf5_SDK_for_Mesh/mesh/prov/src/: nrf_mesh_prov.c prov_beacon.c prov_provisionee.c prov_utils.c provisioning.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.12.0
